# Keil uVision project haier_sizhou.uvproj, settings and files
target haier_sizhou (ARM-ADS)
  device: HW2181FHNQ HR
  cpu: IRAM(0x20000000-0x20001FFF)  IROM(0x00000000-0x00008FFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: haier_sizhou +hex
  c flags: Optim=2 wLevel=2
  c include: ..\cmsis;..\c_file;..\hr8p506;..\h_file
  memory RVCT4: ROM 0x0 size 0x9000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group bootloader
    ./: startup_HR8P506.s
  group Libraries
    ../Libraries/: imu.lib
  group c_file
    ../c_file/: main.c scu.c interrupt.c app.c fylib.c hal.c parameter.c hw2000.c timer.c flash.c altitude.c baro.c altitude1.c state_estimation.lib
  group h_file
    ../h_file/: config.h hw2000.h msic_device.h
